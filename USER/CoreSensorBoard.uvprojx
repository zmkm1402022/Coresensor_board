# Keil uVision project CoreSensorBoard.uvprojx, settings and files
target SensorBoard (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SensorBoard_v1.0 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,EMPL_TARGET_STM32F4,MPU9250
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\HARDWARE\LED;..\HARDWARE\TIMER;..\HARDWARE\ADC;..\HARDWARE\CAN;..\HARDWARE\DS18B20;..\HARDWARE\DS1302;..\HARDWARE\IIC;..\HARDWARE\Ultrasonic;..\HARDWARE\WDG;..\SYSTEM;..\USER;..\FreeRTOS\SystemView\Src\Config;..\FreeRTOS\SystemView\Src\FreeRTOSV9;..\FreeRTOS\SystemView\Src\SEGGER;..\HARDWARE\MPU9250\include;..\HARDWARE\MPU9250\mllite;..\HARDWARE\MPU9250\eMPL-hal;..\HARDWARE\MPU9250
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/CAN/: can.c canard.c
    ../HARDWARE/DS18B20/: DS18.c
    ../HARDWARE/DS1302/: DS1302.c
    ../HARDWARE/Ultrasonic/: ultrasonic.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/IIC/: i2c.c
    ../HARDWARE/MPU9250/: inv_mpu.c inv_mpu_dmp_motion_driver.c MPU9250.c
    ../HARDWARE/MPU9250/mllite/: ml_math_func.c data_builder.c message_layer.c results_holder.c start_manager.c storage_manager.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_dbgmcu.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_can.c stm32f10x_flash.c stm32f10x_i2c.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group README
    ../: README.TXT
  group SystemView
    ../FreeRTOS/SystemView/Src/FreeRTOSV9/Config/: SEGGER_SYSVIEW_Config_FreeRTOS.c
    ../FreeRTOS/SystemView/Src/FreeRTOSV9/: SEGGER_SYSVIEW_FreeRTOS.c
    ../FreeRTOS/SystemView/Src/SEGGER/: SEGGER_RTT.c SEGGER_SYSVIEW.c
